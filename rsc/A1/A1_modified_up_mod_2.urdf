Commit message: Trying kinematic estimation

File: rsc/A1/A1_modified_up_mod_2.urdf (robot description, URDF)
Before this commit: robot A1, 17 links, 16 joints
Links:
- added link realsense_d435
Joints:
- added joint imu_joint: type fixed, parent trunk, child imu_link, origin xyz=0 0 0.1 rpy=0 0 0
